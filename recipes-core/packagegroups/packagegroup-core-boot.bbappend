# This does not fit UOS, drop them.
RDEPENDS_${PN}_remove = "${EFI_PROVIDER} kernel"
