require recipes-core/images/sos-image-common.inc
require recipes-core/images/core-image-minimal.bb
