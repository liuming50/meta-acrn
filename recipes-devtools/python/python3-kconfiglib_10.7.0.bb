inherit pypi setuptools3
require python-kconfiglib.inc
