require recipes-core/images/uos-image-common.inc
require recipes-graphics/images/core-image-clutter.bb
