inherit pypi setuptools
require python-kconfiglib.inc
