require recipes-core/images/sos-image-common.inc
require recipes-graphics/images/core-image-weston.bb
