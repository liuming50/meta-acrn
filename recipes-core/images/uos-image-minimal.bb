require recipes-core/images/uos-image-common.inc
require recipes-core/images/core-image-minimal.bb
